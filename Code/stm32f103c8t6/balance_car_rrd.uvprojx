# Keil uVision project balance_car_rrd.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: balance_car_rrd +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\USER\include\dmp;.\USER\drivers;.\USER\common;.\USER\devices;.\USER\algorithm;.\USER\include\stm32_it;.\USER\application
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ./USER/core/: start.c
  group include
    ./USER/include/stm32_it/: stm32f10x_it.c
    ./USER/include/dmp/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group devices
    ./USER/devices/: mpu6050.c mpu6050_dmp.c oled.c motor.c tb6612fng.c blutooth.c encoders.c
  group drivers
    ./USER/drivers/: pwm.c soft_i2c.c encoder.c systick.c systick.h flash.c flash.h iwdg.c iwdg.h
  group common
    ./USER/common/: debug_uart.c delay.c tool.c typedef.h global_config_macros.h
  group algorithm
    ./USER/algorithm/: filter_rrd.c logic.c pid_rrd.c
  group application
    ./USER/application/: globals.c app.c protocol.c typedef_app.h
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:USART 2.3, Device:DMA 1.3, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:BKP 3.6.0, Device:StdPeriph Drivers:CAN 3.6.0, Device:StdPeriph Drivers:CEC 3.6.0, Device:StdPeriph Drivers:CRC 3.6.0, Device:StdPeriph Drivers:DAC 3.6.0, Device:StdPeriph Drivers:DBGMCU 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:FSMC 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:IWDG 3.6.0, Device:StdPeriph Drivers:PWR 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:RTC 3.6.0, Device:StdPeriph Drivers:SDIO 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0, Device:StdPeriph Drivers:WWDG 3.6.0
